# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: fromelf --bin .\output\Project.axf  --output .\output\Project.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Lib\inc;..\Lib\cmsis;..\user;..\Lib;..\User\Hal_Driver;..\User\Protocol;..\User\Hal_Driver\GPIO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group start
    ../Lib/startup/arm/: startup_stm32f10x_hd.s
  group lib
    ../Lib/cmsis/: core_cm3.c
    ../Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c
  group user
    ../user/: main.c stm32f10x_it.c system_stm32f10x.c
    ../User/Hal_Driver/: hal_key.c hal_motor.c hal_rgb_led.c hal_uart.c hal_temp_hum.c hal_infrared.c hal_adc_dma.c
    ../User/: delay.c
    ../User/Hal_Driver/GPIO/: sa_gpio.c
  group protoclol
    ../User/Protocol/: protocol.c
